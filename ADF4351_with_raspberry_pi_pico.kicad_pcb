# Repository Nero-198/ADF4351_with_raspberry_pi_pico_kicad

## KiCad design ADF4351_with_raspberry_pi_pico.kicad_pcb

Parts:
A1: RaspberryPi_Pico; RaspberryPi_Pico_Common_Unspecified
H1, H2, H3, H4: MountingHole_Pad_MP; MountingHole_3.2mm_M3_Pad_Via
J1, J3: B4B-XH-A_LF__SN_; PinHeader_1x4_P2.5mm_Drill1.1mm; MPN B4B-XH-A(LF)(SN); Digi-Key_PN 455-2249-ND
J2, J6: Conn_01x05_Pin; PinSocket_1x05_P2.54mm_Vertical
J4: Conn_01x03_Socket; PinSocket_1x03_P2.54mm_Vertical
J5: Conn_01x05_Socket; PinSocket_1x05_P2.54mm_Vertical
R1, R2: NC; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; not fitted
R3, R4, R5: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R6: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder

Connections:
+3.3V: A1.36 (3V3), J1.1, J2.1, R1.1, R2.1
+5V: A1.40 (VBUS), J3.1, J5.5
CE: A1.7 (GPIO5), J6.2
CLK: A1.4 (GPIO2), J6.4
DAT: A1.5 (GPIO3), J2.3
Encoder_A: A1.14 (GPIO10), J4.1
Encoder_B: A1.15 (GPIO11), J4.3
Encoder_LED_BLUE: A1.27 (GPIO21), R5.1
Encoder_LED_GREEN: A1.26 (GPIO20), R4.1
Encoder_LED_RED: A1.25 (GPIO19), R3.1
Encoder_PUSH: A1.24 (GPIO18), J5.3, R6.2
GND: A1.3 (GND), A1.8 (GND), A1.13 (GND), A1.18 (GND), A1.23 (GND), A1.28 (GND), A1.38 (GND), H1.MP, H2.MP, H3.MP, H4.MP, J1.2, J2.2, J3.4, J4.2, J6.1, R6.1
I2C0_SCL: A1.22 (GPIO17), J1.3, R1.2
I2C0_SDA: A1.21 (GPIO16), J1.4, R2.2
LD: A1.11 (GPIO8), J6.5
LE: A1.10 (GPIO7), J6.3
MUX: A1.6 (GPIO4), J2.4
unnamed: J5.1, R3.2
unnamed: J5.2, R4.2
unnamed: J5.4, R5.2
PDR: A1.9 (GPIO6), J2.5
UART0_RX: A1.2 (GPIO1), J3.3
UART0_TX: A1.1 (GPIO0), J3.2

Notes on the sheet:
プルアップ用 対象のモジュール基板にプルアップがある場合は付けない
５VじゃないとLEDを駆動出来ない。 ラズピコが耐える事に期待する
to PLL connector
UART connector
to Display i2c connector

Board: 2 copper layers, 62.0 x 52.0 mm, 17 parts (6 on the bottom side), 23 nets.

## Commit log

2025-08-10 init commit
2025-08-11 wip ディスプレイとの接続、PLLとの接続は確定。制御用のボタン部分の作成を要する。
2025-08-11 回路図完成
2025-08-16 マウントホールを追加
2025-08-16 Done. make PCB. make silk. make gerber plot.
2025-08-16 Add gerver zip file
2025-08-17 Remove V1.7z. Add V1.zip
2025-09-04 fix 5*2 connector pin
